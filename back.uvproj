# Keil uVision project back.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC2132/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: back +hex
  group Source Group 1
    ./: start.S
